# IAR project xmega_small.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-xmega-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32a4u ATxmega32A4U
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..\..\conf; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\cpu; ..\..\..\..\..\..\..\..\..\..\xmega\boards\dummy; ..\..\..\..\..\..\..\..\..\..\xmega\utils; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\nvm; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\usb; ..\..\..\..\..\..\..\..\isp\flip; ..\..\..\..\..\..\..; ..\..\..\..\..\..\..\..\..\..\xmega\boards; ..\..\..\..\..\..\..\..\clock; ..\..\..\..\..\..\..\..\..\boards; ..\..\..\..\..\..\..\..\..\utils; ..\..; ..\..\..\..\..; ..\..\..\..; .; ..\..\..\..\..\..\..\udc; ..\..\..\..\..\..\..\..\..\..\xmega\utils\preprocessor; .; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\avr\lib\dlib
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD
  XLINK.XclFile: atxmega32a4u_boot.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..\..\conf; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\cpu; ..\..\..\..\..\..\..\..\..\..\xmega\boards\dummy; ..\..\..\..\..\..\..\..\..\..\xmega\utils; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\nvm; ..\..\..\..\..\..\..\..\..\..\xmega\drivers\usb; ..\..\..\..\..\..\..\..\isp\flip; ..\..\..\..\..\..\..; ..\..\..\..\..\..\..\..\..\..\xmega\boards; ..\..\..\..\..\..\..\..\clock; ..\..\..\..\..\..\..\..\..\boards; ..\..\..\..\..\..\..\..\..\utils; ..\..; ..\..\..\..\..; ..\..\..\..; .; ..\..\..\..\..\..\..\udc; ..\..\..\..\..\..\..\..\..\..\xmega\utils\preprocessor; .
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c
  group common/services/isp/flip/xmega
    ../../../../../../../../isp/flip/xmega/: cstartup.s90 isp.c
    ../../: led.h
  group common/services/usb/class/dfu_flip/device
    ../../../../: udi_dfu_atmel.c udi_dfu_atmel_desc.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega
    ../../conf/: conf_board.h conf_clock.h conf_isp.h conf_usb.h
    ../../: main.c sysclk_opt.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc_dfu_small.c
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c
